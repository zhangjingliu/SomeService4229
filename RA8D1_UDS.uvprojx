# Keil uVision project RA8D1_UDS.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.9.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: RA8D1_UDS +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: v6Lang=3 v6LangP=3 wLevel=1
  c misc: @via/rasc_armclang.via
  c include: .\debug_uart;.\Systick;.\CANFD_DBC;.\canfd;.\UserTask\UDS;.\UserTask\UDS\TP;.\UserTask\UDS\DEM;.\UserTask\UDS\DCM;.\UserTask\Application;.\AES128
  asm misc: --via=via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group Source Group 1
    ./debug_uart/: bsp_debug_uart.c
    ./Systick/: Systick.c
    ./canfd/: bsp_canfd0.c bsp_canfd1.c
    ./CANFD_DBC/: CANFD_A2B.c
    ./UserTask/UDS/TP/: Tp_Can_Drv.c
    ./UserTask/UDS/DEM/: Detdtc.c Detfun.c Dtc_mat.c
    ./UserTask/UDS/DCM/: Dcm_Drv.c Dcm_DrvCfg.c SID2E_WriteDataByldentifier.c SID2E_WriteDataByldentifierCfg.c SID3E_TesterPrsent.c SID3E_TesterPrsentCfg.c SID10_DiagnosticSessionControl.c SID10_DiagnosticSessionControlCfg.c SID11_ECUReset.c SID11_ECUResetCfg.c SID14_ClearDiagnosticInformation.c SID14_ClearDiagnosticInformationCfg.c SID19_ReadDTCInformation.c SID19_ReadDTCInformationCfg.c SID22_ReadDataByldentifier.c SID22_ReadDataByldentifierCfg.c SID27_SecurityAccess.c SID27_SecurityAccessCfg.c SID28_CommunicationControl.c SID28_CommunicationControlCfg.c SID31_RoutineControl.c SID31_RoutineControlCfg.c SID34_RequestDownload.c SID34_RequestDownloadCfg.c SID36_TransferData.c SID36_TransferDataCfg.c SID37_RequestTransferExit.c SID37_RequestTransferExitCfg.c SID85_ControlDTCSetting.c SID85_ControlDTCSettingCfg.c
    ./UserTask/Application/: AB_Swap.c UDS.c
    ./AES128/: aes_cbc_cmac.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
